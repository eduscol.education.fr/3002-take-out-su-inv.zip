# Autodesk Inventor part: VENTOUSE PIECE 4
## iProperties
Created: 2004-11
Part Number: VENTOUSE PIECE 4
Document SubType Name: Modeling
Designer: Bruno
Manufacturer: Standard
Standards Organization: Custom
Author: Bruno
## Feature names
1. Base1
