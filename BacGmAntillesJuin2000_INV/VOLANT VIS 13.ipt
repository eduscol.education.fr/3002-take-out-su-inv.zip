# Autodesk Inventor part: VOLANT VIS 13
## iProperties
Created: 2004-11
Part Number: VOLANT VIS 13
Document SubType Name: Modeling
Designer: Bruno
Manufacturer: Standard
Standards Organization: Custom
Author: Bruno
## Feature names
1. Base1
