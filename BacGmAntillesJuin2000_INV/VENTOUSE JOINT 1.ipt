# Autodesk Inventor part: VENTOUSE JOINT 1
## iProperties
Created: 2004-11
Part Number: VENTOUSE JOINT 1
Document SubType Name: Modeling
Designer: Bruno
Manufacturer: Standard
Standards Organization: Custom
Author: Bruno
## Feature names
1. Base1
