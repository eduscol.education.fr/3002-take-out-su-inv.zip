# Autodesk Inventor part: ANNEAU POUR 36
## iProperties
Created: 2004-11
Part Number: ANNEAU POUR 36
Document SubType Name: Modeling
Designer: Bruno
Manufacturer: Standard
Standards Organization: Custom
Author: Bruno
## Feature names
1. Base1
