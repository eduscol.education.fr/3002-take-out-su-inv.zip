# Autodesk Inventor part: BATI PIECE 1
## iProperties
Created: 2004-11
Part Number: BATI PIECE 1
Document SubType Name: Modeling
Designer: Bruno
Manufacturer: Standard
Standards Organization: Custom
Author: Bruno
## Feature names
1. Base1
