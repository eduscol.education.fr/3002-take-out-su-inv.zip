# Autodesk Inventor part: AIDE SUPPORT 2
## iProperties
Created: 2004-11
Part Number: AIDE SUPPORT 2
Document SubType Name: Modeling
Designer: Bruno
Manufacturer: Standard
Standards Organization: Custom
Author: Bruno
## Feature names
1. Base1
