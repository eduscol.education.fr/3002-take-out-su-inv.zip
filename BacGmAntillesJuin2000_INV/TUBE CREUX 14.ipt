# Autodesk Inventor part: TUBE CREUX 14
## iProperties
Created: 2004-11
Part Number: TUBE CREUX 14
Document SubType Name: Modeling
Designer: Bruno
Manufacturer: Standard
Standards Organization: Custom
Author: Bruno
## Feature names
1. Base1
